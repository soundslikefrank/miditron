# Repository soundslikefrank/miditron

File README.md:

# miditron
midi2cv module best to be used with Elektron devices

## KiCad design hardware/miditron-back.kicad_pcb

Board: 2 copper layers, 39.4 x 109.2 mm, 144 parts (4 on the bottom side), 131 nets.

Parts:
C1, C2, C3, C5, C9, C10, C12, C13, C14, C15, C16, C17, C18, C21, C22, C27, C28, C30, C31, C33, C34, C45, C47, C57: 100n; C_0603_1608Metric
C4, C7, C32, C51, C52, C53, C54: 1u; C_0603_1608Metric
C6, C8: 27p; C_0603_1608Metric
C11, C19: 4u7; C_0603_1608Metric
C20: 220n; C_0603_1608Metric
C23, C24, C25, C26: 22p; C_0603_1608Metric
C29: 10u; C_0603_1608Metric
C35, C36, C37, C38, C39, C40, C41, C42: 10p; C_0603_1608Metric
C43, C44, C46: 10u; C_0805_2012Metric
C48, C49: 22u; CP_Elec_5x5.3
C50: 22u; C_0805_2012Metric
C55, C56: 100p; C_0603_1608Metric
D2: 1N4148; D_SOD-123
D3, D4: 1N5819; D_SOD-123
D5, D6: B72500D0160H060; D_0603_1608Metric
FB1, FB2: 100 @ 100MHz; L_0805_2012Metric
IC1: SN74AHCT244PW; SOP65P640X120-20N
IC2: LP5012PWR; SOP65P640X120-24N
IC3: DAC8564IAPW; SOP65P640X120-16N
IC4: AD5328BRUZ; SOP65P640X120-16N
IC5: ADP150AUJZ-3.3-R7; SOT95P280X100-5N
J1, J2: Conn_02x06_Odd_Even; PinSocket_2x06_P2.54mm_Vertical
J3: Conn_01x10; PinSocket_1x10_P2.54mm_Vertical
J4: Conn_01x12; PinSocket_1x12_P2.54mm_Vertical
J32: Debug; PinHeader_2x05_P1.27mm_Vertical
J33: Eurorack PWR; IDC-Header_2x05_P2.54mm_Vertical
J34: Expander; PinHeader_2x03_P1.27mm_Vertical
J35: SPI3 Testpoint; PinHeader_1x03_P2.54mm_Vertical
L1: 10u; L_0805_2012Metric
R3: 27k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R6, R8: 10k; R_0603_1608Metric
R5: 220R; R_0603_1608Metric
R7: 680R; R_0603_1608Metric
R9, R11, R12, R13, R14, R23: 33k; R_0603_1608Metric
R10, R26, R27, R28, R29, R38, R39, R40, R41, R55, R56: 36k; R_0603_1608Metric
R15, R16, R17, R18: 180k; R_0603_1608Metric
R19, R20, R21, R22, R34, R35, R36, R37, R46, R47, R48, R49: 1k; R_0603_1608Metric
R24: 22k; R_0603_1608Metric
R30, R31, R32, R33, R42, R43, R44, R45, R51, R52: 150k; R_0603_1608Metric
R50: 1k8; R_0603_1608Metric
R53, R54: 200k; R_0603_1608Metric
R57, R58: 100R; R_0603_1608Metric
U1: AT24C256C; SOIC-8_3.9x4.9mm_P1.27mm
U2: 6N137; SMDIP-8_W9.53mm
U3: STM32F401RBTx; LQFP-64_10x10mm_P0.5mm
U4: OPA4172; TSSOP-14_4.4x5mm_P0.65mm
U5, U6: TL074; TSSOP-14_4.4x5mm_P0.65mm
U7: LM1117-3.3; SOT-223
U8: LM1117-5.0; SOT-223
U9: LM4040DBZ-10; SOT-23
U10: MCP6002-xMS; SOIC-8_3.9x4.9mm_P1.27mm
Y1: X50328MSB2GI; Crystal_SMD_5032-2Pin_5.0x3.2mm

Connections:
1_16_out_back: IC1.5, J3.4
1_16_out_l: IC1.15, U3.26
+3.3VA: C7.1, C9.1, C18.2, C19.1, C27.2, C29.1, C54.1, IC3.4, IC4.3, IC5.5, U3.13
+3V3: C1.1, C2.1, C3.1, C10.1, C13.1, C14.1, C15.1, C16.1, C17.2, C45.1, C46.1, C57.1, IC2.4, IC3.12, J2.11, J32.1, J34.5, R4.1, R6.2, U1.8, U2.8, U3.1, U3.19, U3.32, U3.48, U3.64, U7.2, U10.8
+5V: C5.1, C47.1, C50.2, C52.1, IC1.20, IC5.1, IC5.3, U7.3, U8.2
+12V: D4.2, J33.9, J33.10
-12V: D3.1, J33.1, J33.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.1, C13.2, C14.2, C15.2, C16.2, C17.1, C18.1, C19.2, C20.1, C21.1, C22.1, C27.1, C28.1, C29.2, C30.1, C31.1, C32.2, C33.2, C34.1, C43.2, C44.1, C45.2, C46.2, C47.2, C48.1, C49.1, C50.1, C51.2, C52.2, C53.2, C54.2, C57.2, D5.2, D6.2, IC1.1, IC1.10, IC1.19, IC2.1, IC2.2, IC2.3, IC2.6, IC2.18, IC3.5, IC3.6, IC3.13, IC3.14, IC3.15, IC3.16, IC4.1, IC4.14, IC5.2, J2.8, J2.12, J3.1, J3.10, J32.3, J32.5, J32.9, J33.3, J33.4, J33.5, J33.6, J33.7, J33.8, J34.4, J34.6, R3.1, R8.1, R10.1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
unnamed: C4.1, IC2.10
unnamed: C8.1, R7.1, Y1.2
unnamed: C11.1, U3.30
unnamed: C23.1, R11.1, R15.2, U4.2
unnamed: C23.2, R19.2, U4.1
unnamed: C24.1, R12.1, R16.2, U4.13
unnamed: C24.2, R20.2, U4.14
unnamed: C25.1, R13.1, R17.2, U4.6
unnamed: C25.2, R21.2, U4.7
unnamed: C26.1, R14.1, R18.2, U4.9
unnamed: C26.2, R22.2, U4.8
unnamed: C35.1, R34.2, U5.1
unnamed: C35.2, R26.1, R30.2, U5.2
unnamed: C36.1, R35.2, U5.7
unnamed: C36.2, R27.1, R31.2, U5.6
unnamed: C37.1, R36.2, U5.8
unnamed: C37.2, R28.1, R32.2, U5.9
unnamed: C38.1, R37.2, U5.14
unnamed: C38.2, R29.1, R33.2, U5.13
unnamed: C39.1, R46.2, U6.1
unnamed: C39.2, R38.1, R42.2, U6.2
unnamed: C40.1, R47.2, U6.7
unnamed: C40.2, R39.1, R43.2, U6.6
unnamed: C41.1, R48.2, U6.8
unnamed: C41.2, R40.1, R44.2, U6.9
unnamed: C42.1, R49.2, U6.14
unnamed: C42.2, R41.1, R45.2, U6.13
unnamed: C44.2, L1.2, U8.3
unnamed: C55.1, R51.1, R53.2, R55.2, U10.2
unnamed: C55.2, R55.1, R57.2, U10.1
unnamed: C56.1, R52.1, R54.2, R56.2, U10.6
unnamed: C56.2, R56.1, R58.2, U10.7
unnamed: D2.1, R5.1, U2.2
unnamed: D3.2, FB1.2
unnamed: D4.1, FB2.2
unnamed: IC2.8, R4.2
unnamed: IC2.9, R3.2
unnamed: R8.2, U3.60
VCC: C21.2, C28.2, C31.2, C43.1, C49.2, FB2.1, L1.1, U4.4, U5.4, U6.4
VEE: C22.2, C30.2, C34.2, C48.2, C51.1, FB1.1, R50.2, U4.11, U5.11, U6.11
button_a_back: J2.3, U3.8
button_b_back: J2.4, U3.9
button_c_back: J2.5, U3.10
button_d_back: J2.6, U3.11
clock_out_back: IC1.9, J3.2
clock_out_l: IC1.11, U3.24
cv_in_a: R57.1, U3.14
cv_in_a_back: D5.1, J2.1, R51.2
cv_in_b: R58.1, U3.15
cv_in_b_back: D6.1, J2.2, R52.2
dac4_out_a_back: J4.12, R15.1, R19.1
dac4_out_b_back: J4.11, R16.1, R20.1
dac4_out_c_back: J4.10, R18.1, R22.1
dac4_out_d_back: J4.9, R17.1, R21.1
dac8_out_a_back: J4.8, R31.1, R35.1
dac8_out_b_back: J4.5, R32.1, R36.1
dac8_out_c_back: J4.1, R33.1, R37.1
dac8_out_d_back: J4.4, R30.1, R34.1
dac8_out_e_back: J4.2, R42.1, R46.1
dac8_out_f_back: J4.3, R45.1, R49.1
dac8_out_g_back: J4.7, R44.1, R48.1
dac8_out_h_back: J4.6, R43.1, R47.1
gate_out_a_back: IC1.18, J3.6
gate_out_a_l: IC1.2, U3.33
gate_out_b_back: IC1.16, J3.7
gate_out_b_l: IC1.4, U3.34
gate_out_c_back: IC1.14, J3.8
gate_out_c_l: IC1.6, U3.35
gate_out_d_back: IC1.12, J3.9
gate_out_d_l: IC1.8, U3.36
hse_in: C6.1, U3.5, Y1.1
hse_out: R7.2, U3.6
i2c1_scl: U1.6, U3.58
i2c1_sda: U1.5, U3.59
i2c2_scl: IC2.7, U3.29
i2c2_sda: IC2.5, U3.55
i2c3_scl: J34.2, U3.41
i2c3_sda: J34.1, U3.40
jack_detect_back: J2.7, U3.16
jtag_reset: C12.2, J32.10, U3.7
jtag_swclk: J32.4, U3.49
jtag_swdio: J32.2, U3.46
led_out_a_b_back: IC2.14, J1.3
led_out_a_g_back: IC2.13, J1.2
led_out_a_r_back: IC2.12, J1.1
led_out_b_b_back: IC2.17, J1.6
led_out_b_g_back: IC2.16, J1.5
led_out_b_r_back: IC2.15, J1.4
led_out_c_b_back: IC2.21, J1.9
led_out_c_g_back: IC2.20, J1.8
led_out_c_r_back: IC2.19, J1.7
led_out_d_b_back: IC2.24, J1.12
led_out_d_g_back: IC2.23, J1.11
led_out_d_r_back: IC2.22, J1.10
midi_in: R6.1, U2.6, U3.43
midi_in+_back: J2.10, R5.2
midi_in-_back: D2.2, J2.9, U2.3
ref_-10v: C53.1, R50.1, R53.1, R54.1, U9.2
ref_dac4: R9.2, R10.2, U4.3, U4.5, U4.10, U4.12
ref_dac8: R23.2, R24.2, U5.3, U5.5, U5.10, U5.12, U6.3, U6.5, U6.10, U6.12
run_out_back: IC1.7, J3.3
run_out_l: IC1.13, U3.25
spi1_mosi: IC3.11, U3.23
spi1_nss: IC3.9, U3.20
spi1_sck: IC3.10, U3.21
spi3_mosi: IC4.15, J35.2, U3.53
spi3_nss: IC4.2, J35.3, U3.50
spi3_sck: IC4.16, J35.1, U3.51
v_out_dac4_a: IC3.1, R11.2
v_out_dac4_b: IC3.2, R12.2
v_out_dac4_c: IC3.7, R14.2
v_out_dac4_d: IC3.8, R13.2
v_out_dac8_a: IC4.4, R27.2
v_out_dac8_b: IC4.5, R28.2
v_out_dac8_c: IC4.6, R29.2
v_out_dac8_d: IC4.7, R26.2
v_out_dac8_e: IC4.10, R38.2
v_out_dac8_f: IC4.11, R41.2
v_out_dac8_g: IC4.12, R40.2
v_out_dac8_h: IC4.13, R39.2
v_ref_dac4: C20.2, C32.1, C33.1, IC3.3, IC4.8, IC4.9, R9.1, R23.1
var_out_back: IC1.3, J3.5
var_out_l: IC1.17, U3.27

## KiCad design hardware/miditron-front.kicad_pcb

Board: 2 copper layers, 39.4 x 109.2 mm, 34 parts (27 on the bottom side), 45 nets.

Parts:
D1: BAT54S; SOT-23
J5, J6: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical
J7: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical
J8: Conn_01x12; PinHeader_1x12_P2.54mm_Vertical
J9: SD-50BV
J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J20, J21, J22, J23, J24, J25, J26, J27, J28, J29, J30, J31: PJ398SM; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles
R1, R2: 100k; R_0603_1608Metric
S1, S2, S3, S4: TC002-N11AS1XKT-RGB; TC002N11AS1XKTRGB

Connections:
1_16_out_front: J7.4, J22.T
+3V3: D1.2, J6.11, S1.5, S2.5, S3.5, S4.5
GND: D1.1, J6.8, J6.12, J7.1, J7.10, J10.S, J11.S, J12.S, J13.S, J14.S, J15.S, J16.S, J17.S, J18.S, J19.S, J20.S, J21.S, J22.S, J23.S, J24.S, J25.S, J26.S, J27.S, J28.S, J29.S, J30.S, J31.S, S1.3, S1.4, S2.3, S2.4, S3.3, S3.4, S4.3, S4.4
unnamed: J15.TN, R1.1
unnamed: J21.TN, R2.1
button_a_front: J6.3, S1.1, S1.2
button_b_front: J6.4, S3.1, S3.2
button_c_front: J6.5, S2.1, S2.2
button_d_front: J6.6, S4.1, S4.2
clock_out_front: J7.2, J10.T
cv_in_a_front: J6.1, J15.T
cv_in_b_front: J6.2, J21.T
dac4_out_a_front: J8.12, J11.T
dac4_out_b_front: J8.11, J12.T
dac4_out_c_front: J8.10, J13.T
dac4_out_d_front: J8.9, J14.T
dac8_out_a_front: J8.8, J23.T
dac8_out_b_front: J8.5, J28.T
dac8_out_c_front: J8.1, J24.T
dac8_out_d_front: J8.4, J29.T
dac8_out_e_front: J8.2, J25.T
dac8_out_f_front: J8.3, J30.T
dac8_out_g_front: J8.7, J26.T
dac8_out_h_front: J8.6, J31.T
gate_out_a_front: J7.6, J17.T
gate_out_b_front: J7.7, J18.T
gate_out_c_front: J7.8, J19.T
gate_out_d_front: J7.9, J20.T
jack_detect_front: D1.3, J6.7, R1.2, R2.2
led_out_a_b_front: J5.3, S1.8
led_out_a_g_front: J5.2, S1.6
led_out_a_r_front: J5.1, S1.7
led_out_b_b_front: J5.6, S3.8
led_out_b_g_front: J5.5, S3.6
led_out_b_r_front: J5.4, S3.7
led_out_c_b_front: J5.9, S2.8
led_out_c_g_front: J5.8, S2.6
led_out_c_r_front: J5.7, S2.7
led_out_d_b_front: J5.12, S4.8
led_out_d_g_front: J5.11, S4.6
led_out_d_r_front: J5.10, S4.7
midi_in+_front: J6.10, J9.2
midi_in-_front: J6.9, J9.4
run_out_front: J7.3, J16.T
var_out_front: J7.5, J27.T

## Code that names these connections

File hardware/support/stm32cubemx.ioc (part):

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Mcu.Name=STM32F401R(B-C)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32F401RBTx
PA0-WKUP.GPIOParameters=GPIO_Label
PA0-WKUP.GPIO_Label=sense
PA0-WKUP.Signal=ADCx_IN0
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=feel
PA1.Signal=ADCx_IN1
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=jack_detect
PA2.Signal=GPIO_Output
PA5.Mode=TX_Only_Simplex_Unidirect_Master
PA5.Signal=SPI1_SCK
PA7.Mode=TX_Only_Simplex_Unidirect_Master
PA7.Signal=SPI1_MOSI
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=_1_16_out
PB0.Signal=GPIO_Output
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=var_out
PB1.Signal=GPIO_Output
PB10.Mode=I2C
PB10.Signal=I2C2_SCL
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=gate_out_a
PB12.Signal=GPIO_Output
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=gate_out_b
PB13.Signal=GPIO_Output
PB14.GPIOParameters=GPIO_Label
PB14.GPIO_Label=gate_out_c
PB14.Signal=GPIO_Output
PB15.GPIOParameters=GPIO_Label
PB15.GPIO_Label=gate_out_d
PB15.Signal=GPIO_Output
PB3.Mode=I2C
PB3.Signal=I2C2_SDA
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PC0.GPIOParameters=GPIO_Label
PC0.GPIO_Label=button_a
PC0.Signal=GPIO_Input
PC1.GPIOParameters=GPIO_Label
PC1.GPIO_Label=button_b
PC1.Signal=GPIO_Input
PC10.Mode=TX_Only_Simplex_Unidirect_Master
PC10.Signal=SPI3_SCK
PC12.Mode=TX_Only_Simplex_Unidirect_Master
PC12.Signal=SPI3_MOSI
PC2.GPIOParameters=GPIO_Label
PC2.GPIO_Label=button_c
PC2.Signal=GPIO_Input
PC3.GPIOParameters=GPIO_Label
PC3.GPIO_Label=button_d
PC3.Signal=GPIO_Input
PC4.GPIOParameters=GPIO_Label
PC4.GPIO_Label=clock_out
PC4.Signal=GPIO_Output
PC5.GPIOParameters=GPIO_Label
PC5.GPIO_Label=run_out
PC5.Signal=GPIO_Output
PH0\ -\ OSC_IN.Mode=HSE-External-Oscillator
PH0\ -\ OSC_IN.Signal=RCC_OSC_IN
PH1\ -\ OSC_OUT.Mode=HSE-External-Oscillator
PH1\ -\ OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=25000000
RCC.SYSCLKFreq_VALUE=16000000
board=custom

## Commit log

2021-05-13 Add preliminary firmware folder
2021-05-13 Add preliminary KiCad project
2021-05-13 Tiny cleanup
2021-05-13 Use a heapless queue for usart
2021-05-14 Use systick interrupt instead of loop
2021-05-14 Split up driver and interrupt files
2021-05-16 Refactor statics to add midi parser
2021-05-16 MESSAGE_BUFFER -> MIDI_MESSAGE_BUFFER
2021-05-16 Add const for midi message buffer length
2021-05-17 Add simple dac8564 SPI transfer
2021-05-17 Use embedded-midi instead of wmidi
2021-05-18 Remove superfluous try_from MidiMessage
2021-05-18 Add working i2c example
2021-05-18 Move notes
2021-05-20 Add DAC5578 driver
2021-05-20 Add first schematics
2021-05-20 Remove root gitignore, check in Cargo.lock
2021-05-20 Update DAC versions
2021-05-21 Switch to STM32F446
2021-05-21 Add wireframes
2021-05-21 Add wiki
2021-05-22 Refactor drivers (with confidence)
2021-05-22 Use const values for clock frequencies
2021-05-23 Create own instances of dac drivers
2021-05-23 Add first draft of router (replaces voices)
2021-05-23 Add amplifier circuits for DACs
2021-05-24 Introduce dispatcher concept
2021-05-24 Generate DAC commands and set voltages
2021-05-24 Add Gates driver
2021-05-24 Introduce commands
2021-05-25 Default to more sensible midi channels
2021-05-25 Add to wiki
2021-05-28 Add preliminary push button and led drivers
2021-05-28 LED react on short press
2021-05-28 Clean up clocky stuff
2021-05-28 Add preliminary support for the lp5012
2021-05-28 Improve dispatcher destination implementation
2021-05-30 Add clock and counter for better periph timing
2021-05-31 Move clock into own module
2021-05-31 Add experimental multi mod
2021-06-02 Resources refactor
2021-06-02 Use enum instead of struct for input data
2021-06-03 Use stm32f410rbtx
2021-06-03 Add utils module
2021-06-07 Add preliminary eeprom driver
2021-06-07 Switch to stm32f401
2021-06-08 Make buttons pull-up
2021-06-08 Add handling of velocity to test mod outs
2021-06-08 Fix eeprom memory address in store_page
2021-06-09 Add eeprom read_page function
2021-06-09 Add two button press detection for calibration
2021-06-10 Handle simultaneous button presses
2021-06-11 Add calibrator
2021-06-11 Account for actual gain in DAC4
2021-06-11 Account for actual gain in DAC8
2021-06-11 Adjust for four buttons
2021-06-11 Add calibrator result
2021-06-11 Add stop action
2021-06-11 Add full calibration workflow (1 ch)
2021-06-12 Add eeprom magic byte for calibration
2021-06-12 Establish calibration for all channels
2021-06-13 Run counter on first call of elapsed_
2021-06-13 Specify optimization level for release profile
2021-06-14 Wait for 10ms between eeprom writes
2021-06-14 Fix LED stop action
2021-06-14 Use release target for gdb debugging
2021-06-14 Reset calibrator after its work
2021-06-14 Simpler buffer for push buttons
2021-06-14 Destinations refactor
2021-06-14 Use AtomicU32 for clock
2021-07-27 Move to single schema tree
2021-07-30 Move to F401RB (breadboard)
2021-08-07 First preliminary board design
2021-08-07 Ignore manufacturing files
2021-08-07 Add panel file
2021-08-09 Layed out stretched design
2021-08-21 Add panel design
2021-08-21 Add logo
2021-08-21 Fix issues before manufacturing first prototype
    The MIDI jack footprint issue (existent in the first hardware made) is also already fixed in here.
2021-08-21 Add pink and yellow colors
2021-08-21 Tiny changes for hardware prototype debugging
2021-08-21 Fix jack switches connected to ground
2021-10-08 Adjust for new rustc and cargo-embed
2021-10-09 Add the clocks destination, gates->digital_outs
2021-10-09 Add run, resume and stop
2021-10-09 prevent big numbers in pulse counter
2021-10-10 Swap center buttons and LEDs due to hardware error
2021-10-10 Blink corresponding LEDs in calibrator
2021-10-12 proper licensing
2021-12-02 remove wiki
2021-12-02 add component models as submodule
2021-12-02 use tim5 for initial delays (race condition?)
2021-12-02 add stm32cubemx project file
2022-01-27 update models
2022-01-27 tiny update for midi cc support
2022-01-27 use electrolytic caps for +/-12V rails
2022-01-27 wire up ad5328
2022-01-27 make back compatible with old front
2022-01-27 split up pcb into two projects
2022-01-27 update to kicad 6
2022-01-27 upgrade stm32f4xx-hal to 0.10.1
2022-03-11 Rename config.toml
2022-03-11 Clippy
2022-03-27 Add pic
